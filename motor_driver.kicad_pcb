# Repository Nero-198/IGBT_3phase_Driver

## KiCad design motor_driver.kicad_pcb

Parts:
J2: Screw_Terminal_01x03; TerminalBlock_Dinkle_DT-55-B01X-03_P10.00mm
J3: Screw_Terminal_01x02; TerminalBlock_Dinkle_DT-55-B01X-02_P10.00mm
U1: 74HCT04; DIP-14_W7.62mm_LongPads

Connections:
GNDD: J3.2, U1.7 (GND); also elsewhere on the board
unnamed: J3.1, U1.14 (VCC)
S1: J2.1, U1.1; also elsewhere on the board
S2: U1.2; also elsewhere on the board
S3: J2.2, U1.3; also elsewhere on the board
S4: U1.4; also elsewhere on the board
S5: J2.3, U1.5; also elsewhere on the board
S6: U1.6; also elsewhere on the board

Parts:
J1: Screw_Terminal_01x02; TerminalBlock_Dinkle_DT-55-B01X-02_P10.00mm

Connections:
+VDC: J1.1; also elsewhere on the board
GND: J1.2; also elsewhere on the board

Notes on the sheet:
200V

Parts:
C1, C2, C5, C6, C9, C10: 0.1u; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C3, C4, C7, C8, C11, C12: 470u; CP_Radial_D12.5mm_P5.00mm
C13, C14, C15, C16, C17, C18: X; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2, D3, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21: D; D_SMA_Handsoldering
D4, D5, D6, D7, D8, D9: D_TVS_20V; D_SMA_Handsoldering
J8: Screw_Terminal_01x03; TerminalBlock_Dinkle_DT-55-B01X-03_P10.00mm
Q1, Q2, Q3, Q4, Q5, Q6: Q_NIGBT_GCE; TO-247-3_Vertical
R1, R2, R3, R4, R5, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8, R13, R14, R19, R20: 510; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10, R15, R16, R21, R22: 8.2; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R17, R18, R23, R24: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25, R26, R27, R28, R29, R30: X; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4, U5, U6, U7, U8, U9: TLP250; DIP-8_W7.62mm_LongPads

Connections:
+15V: C2.1, C4.1, C6.1, C8.1, C10.1, C12.1, D1.2 (A), D2.2 (A), D3.2 (A), U5.8 (VCC), U7.8 (VCC), U9.8 (VCC)
+VDC: C13.1, C14.1, C15.1, D13.1 (K), D14.1 (K), D15.1 (K), Q1.2 (C), Q3.2 (C), Q5.2 (C); also elsewhere on the board
GND: C2.2, C4.2, C6.2, C8.2, C10.2, C12.2, C16.2, C17.2, C18.2, D5.1 (A1), D7.1 (A1), D9.1 (A1), D10.2 (A), D11.2 (A), D12.2 (A), Q2.3 (E), Q4.3 (E), Q6.3 (E), R12.1, R18.1, R24.1, R28.1, R29.1, R30.1, U5.5 (VEE), U7.5 (VEE), U9.5 (VEE); also elsewhere on the board
GNDD: R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, U4.3 (C), U5.3 (C), U6.3 (C), U7.3 (C), U8.3 (C), U9.3 (C); also elsewhere on the board
unnamed: C1.1, C3.1, D1.1 (K), U4.8 (VCC)
unnamed: C5.1, C7.1, D2.1 (K), U6.8 (VCC)
unnamed: C9.1, C11.1, D3.1 (K), U8.8 (VCC)
unnamed: D4.2 (A2), Q1.1 (G), R9.2, R11.2
unnamed: D5.2 (A2), Q2.1 (G), R10.2, R12.2
unnamed: D6.2 (A2), Q3.1 (G), R15.2, R17.2
unnamed: D7.2 (A2), Q4.1 (G), R16.2, R18.2
unnamed: D8.2 (A2), Q5.1 (G), R21.2, R23.2
unnamed: D9.2 (A2), Q6.1 (G), R22.2, R24.2
unnamed: C1.2, C3.2, D4.1 (A1), D10.1 (K), D13.2 (A), D16.1 (K), D19.2 (A), J8.1, Q1.3 (E), Q2.2 (C), R11.1, R25.1, R28.2, U4.5 (VEE)
unnamed: C5.2, C7.2, D6.1 (A1), D11.1 (K), D14.2 (A), D17.1 (K), D20.2 (A), J8.2, Q3.3 (E), Q4.2 (C), R17.1, R26.1, R29.2, U6.5 (VEE)
unnamed: C9.2, C11.2, D8.1 (A1), D12.1 (K), D15.2 (A), D18.1 (K), D21.2 (A), J8.3, Q5.3 (E), Q6.2 (C), R23.1, R27.1, R30.2, U8.5 (VEE)
unnamed: C13.2, D16.2 (A), R25.2
unnamed: C14.2, D17.2 (A), R26.2
unnamed: C15.2, D18.2 (A), R27.2
unnamed: C16.1, D19.1 (K)
unnamed: C17.1, D20.1 (K)
unnamed: C18.1, D21.1 (K)
unnamed: R9.1, U4.6 (VO), U4.7 (VO)
unnamed: R10.1, U5.6 (VO), U5.7 (VO)
unnamed: R15.1, U6.6 (VO), U6.7 (VO)
unnamed: R16.1, U7.6 (VO), U7.7 (VO)
unnamed: R21.1, U8.6 (VO), U8.7 (VO)
unnamed: R22.1, U9.6 (VO), U9.7 (VO)
unnamed: R1.1, R7.2, U4.2 (A)
unnamed: R2.1, R8.2, U5.2 (A)
unnamed: R3.1, R13.2, U6.2 (A)
unnamed: R4.1, R14.2, U7.2 (A)
unnamed: R5.1, R19.2, U8.2 (A)
unnamed: R6.1, R20.2, U9.2 (A)
S1: R7.1; also elsewhere on the board
S2: R8.1; also elsewhere on the board
S3: R13.1; also elsewhere on the board
S4: R14.1; also elsewhere on the board
S5: R19.1; also elsewhere on the board
S6: R20.1; also elsewhere on the board

Notes on the sheet:
200V
耐圧215V以上！

Board: 2 copper layers, 199.4 x 139.7 mm, 86 parts (39 on the bottom side), 41 nets.
